# Keil uVision project gd32a71x.uvprojx, settings and files
target gd32a71x (6160000::V6.16::ARMCLANG)
  device: GD32A711AR:CM7_0 GigaDevice
  pack: GigaDevice.GD32A7xx_DFP.1.1.0
  cpu: IRAM(0x24000000,0x8000) IRAM2(0x00000000,0x8000) IROM(0x08000000,0x100000) IROM2(0x08800000,0x20000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: gd32a71x
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32A711X_A712X
  c misc: -Wassign-enum
  c include: ..\firmware\CMSIS\device;..\firmware\CMSIS\core;..\firmware\GD32A7xx_standard_peripheral\Include;..\app
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8800000 size 0x20000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x24000000 size 0x8000
  memory RVCT10: RAM 0x0 size 0x8000
  group app
    ../app/: main.c systick.c
    ../firmware/CMSIS/device/: gd32a7xx_it.c
  group firmware/cmsis
    ../firmware/CMSIS/device/ARM/: startup_gd32a711x_a712x.s
    ../firmware/CMSIS/device/: system_gd32a71xx_a74xx.c gd32a7xx_err_report.c
  group firmware/driver
    ../firmware/GD32A7xx_standard_peripheral/Source/: gd32a7xx_adc.c gd32a7xx_bkp.c gd32a7xx_busim.c gd32a7xx_can.c gd32a7xx_cltcfg.c gd32a7xx_cmp.c gd32a7xx_crc.c gd32a7xx_dac.c gd32a7xx_dbg.c gd32a7xx_dma.c gd32a7xx_enet.c gd32a7xx_exti.c gd32a7xx_extmpu.c gd32a7xx_fmc.c gd32a7xx_fmu.c gd32a7xx_fwdgt.c gd32a7xx_gdap.c gd32a7xx_gpio.c gd32a7xx_hsmif.c gd32a7xx_hwsem.c gd32a7xx_i2c.c gd32a7xx_imicu.c gd32a7xx_irm.c gd32a7xx_jdc.c gd32a7xx_linflexd_lin.c gd32a7xx_linflexd_uart.c gd32a7xx_mcmu.c gd32a7xx_mfcom.c gd32a7xx_misc.c gd32a7xx_mtc.c gd32a7xx_pmu.c gd32a7xx_prpu.c gd32a7xx_qspi.c gd32a7xx_rcu.c gd32a7xx_rtc.c gd32a7xx_spi.c gd32a7xx_sram_tcm.c gd32a7xx_stcm.c gd32a7xx_syscfg.c gd32a7xx_timer.c gd32a7xx_trigsel.c gd32a7xx_wwdgt.c
