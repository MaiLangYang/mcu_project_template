# Keil uVision project template_a503c.uvprojx, settings and files
target template_a503c (6160000::V6.16::ARMCLANG)
  device: GD32A503CC GigaDevice
  pack: GigaDevice.GD32A50x_DFP.1.2.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: template_a503c
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32A50X
  c include: ..\app;..\bsp;..\drivers;..\firmware\GD32A50x_standard_peripheral\Include;..\firmware\CMSIS;..\firmware\CMSIS\GD\GD32A50x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../app/: main.c app.c
  group BSP
    ../bsp/: board.c gd32a50x_it.c retarget.c systick.c
  group Drivers
    ../drivers/: drv_adc.c drv_i2c.c drv_usart.c
  group CMSIS
    ../firmware/CMSIS/GD/GD32A50x/Source/: system_gd32a50x.c
  group GD32A50x_StdPeriph
    ../firmware/GD32A50x_standard_peripheral/Source/: gd32a50x_adc.c gd32a50x_gpio.c gd32a50x_i2c.c gd32a50x_misc.c gd32a50x_rcu.c gd32a50x_syscfg.c gd32a50x_usart.c
  group Startup
    ../firmware/CMSIS/GD/GD32A50x/Source/ARM/: startup_gd32a50x.s
  group Doc
    ../: README.md
software components: CMSIS:CORE 5.2.0
